#enable gnuradio-companion
PACKAGECONFIG_append = " grc " 
